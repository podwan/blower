# Keil uVision project Framework.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431C8Tx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_blower
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../Source/: Initialize.c Main.c Startup.s Adc.c
  group Include
    ../Include/: Define.h Initialize.h Main.h stm32g431.h Adc.h
  group Readme
    ../Readme/: Description.txt
  group CoreInc
    ../Include/: CoreDef.h UserParams.h
