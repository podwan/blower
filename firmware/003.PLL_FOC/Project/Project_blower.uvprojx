# Keil uVision project Project_blower.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blower +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../Source/: Initialize.c Main.c Startup.s Led.c Key.c Motor.c Switch.c Heat.c Adc.c Math.c Protect.c Flash.c
  group Include
    ../Include/: Define.h Initialize.h Main.h stm32g431.h Led.h Key.h Motor.h Switch.h Heat.h Adc.h Math.h Protect.h Flash.h
  group Readme
    ../Readme/: Description.txt
  group Driver
    ../Source/: Current.c Pi.c Voltage.c Pll.c Core.c
  group CoreInc
    ../Include/: Current.h Pi.h Voltage.h Pll.h Core.h CoreDef.h UserParams.h
